# Keil uVision project STM32_yukun.uvproj, settings and files
target STM32F407_Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32_yukun
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./src/Startup/: startup_stm32f4xx.s
target STM32F407_RAM (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: STM32_yukun
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  memory RVCT4: ROM 0x2000000 size 0x1000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
